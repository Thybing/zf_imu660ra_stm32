# Keil uVision project F103ZET6.uvprojx, settings and files
target F103ZET6 (6220000::V6.22::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103ZET6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/;../User/menu_nest_lib/inc;..\User\attitude_algorithm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User/imu660ra
    ../User/imu660ra/: zf_device_imu_interface.c zf_device_imu660ra.c
  group User/ssd1306
    ../User/ssd1306/: ssd1306.c ssd1306_fonts.c
  group User/menu_nest
    ../User/menu_nest_lib/src/menu_nest/: heap_1.c interaction.c item.c menu.c page.c render.c
    ../User/menu_nest_lib/src/menu_nest_tiny/: display.c item_auto_variable.c item_cstr.c item_page_entrance.c item_static_variable.c page_base.c page_hibernate.c
    ../User/imu660ra/: zf_device_imu963ra.c
  group User/soft_iic
    ../User/soft_iic/: zf_driver_soft_iic.c
  group User/attitude_algorithm
    ../User/attitude_algorithm/: attitude_algorithm.c pose.c pose_math.c
software components: CMSIS:CORE 6.1.0
